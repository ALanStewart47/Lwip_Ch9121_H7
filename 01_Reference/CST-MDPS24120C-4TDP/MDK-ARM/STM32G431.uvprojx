# Keil uVision project STM32G431.uvprojx, settings and files
target STM32G431 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G431_ +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: "D:\OneDrive\github\psi_ms\spi_communication\CST-MDPS24200C-4TDP_V0.1.2 - slave\MDK-ARM\Keil5_disp_size_bar_v0.3.exe"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Protocol;../Bsp/inc;../App/inc;../Bsp/W5500;../Bsp/W5500/ioLibrary_Driver-master;../Bsp/W5500/ioLibrary_Driver-master/Internet/DHCP;../Bsp/W5500/ioLibrary_Driver-master/Ethernet;../Bsp/W5500/ioLibrary_Driver-master/Ethernet/W5500;../Bsp/log/inc;../RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8003800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group App/Core
    ../App/src/: app.c app_light.c app_uart.c app_flash.c app_trig.c app_router.c app_key_display.c app_prog_trig.c app_adc_handle.c app_master_command.c app_slave_param_sync.c
  group App/Protocol
    ../Protocol/: protocol_public.c protocol_transfer.c protocol_new_handle.c protocol_old_handle.c protocol_old_extend_handle.c
  group Bsp/Driver
    ../Bsp/src/: stm32_tm1637.c bsp_key.c bsp_tim_pwm.c bsp_timer.c bsp_trig_gpio.c bsp_spi_bus_dma.c bsp_hcf4051.c
  group Bsp/W5500
    ../Bsp/W5500/: bsp_w5500.c app_w5500.c wiz_interface.c basic_crc.c
    ../Bsp/W5500/ioLibrary_Driver-master/Internet/DHCP/: dhcp.c
    ../Bsp/W5500/ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ../Bsp/W5500/ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_iwdg.c stm32g4xx_ll_spi.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_ll_tim.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0
